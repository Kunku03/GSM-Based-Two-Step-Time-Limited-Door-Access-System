# Keil uVision project majorproject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: majorproject +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s door.c door_cgram.c eint.c gsm.c Keypad.c lcd.c main.c main_dly.c majorproject.c otp.c rtc.c spi.c spi_eeprom.c switch.c uart.c user.c
